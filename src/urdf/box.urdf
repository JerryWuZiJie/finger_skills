Commit message: change box.urdf shape from 0.15, 0.15, 0.1 to 0.1, 0.1, 0.1

File: src/urdf/box.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- link boxLink: geometry collision box size=0.1 0.1 0.1; visual box size=0.1 0.1 0.1
